# Keil uVision project AstroMountDriver.uvprojx, settings and files
target AstroMountDriver (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: AstroMountDriver
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Inc;                                                                                ../Drivers/STM32F1xx_HAL_Driver/Inc;                                                                                ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                                                                ../Drivers/CMSIS/Include;                                                                                ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                                                   ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                   ../Middlewares/ST/STM32_USB_Device_Library/Class/CustomHID/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: usbd_customhid.c usb_device.c usbd_custom_hid_if.c tim.c usbd_desc.c gpio.c usbd_conf.c stm32f1xx_it.c main.c spi.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_pcd.c stm32f1xx_ll_usb.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_spi.c stm32f1xx_hal_gpio_ex.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_ctlreq.c usbd_core.c usbd_ioreq.c
  group Logic
    ../Logic/Src/: Logic.cpp Encoder.cpp Config.cpp
software components: CMSIS:CORE 4.3.0
